VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
MACRO TSV_LANDING
 CLASS COVER BUMP ;
 ORIGIN 0 0 ;
 SIZE 5 BY 5 ;
 PIN PAD
  DIRECTION INOUT ;
  USE SIGNAL ;
  PORT
   LAYER M1 ;
   RECT -2.5 -2.5 2.5 2.5 ;
  END
 END PAD
END TSV_LANDING
END LIBRARY
